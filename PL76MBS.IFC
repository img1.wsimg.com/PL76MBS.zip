Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: PL76MBS.IFC
Time: 2023-08-24T03:09:18
Written by: SwIFC
Made in: SolidWorks 2022

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 mm

# IfcBuildingElementProxy: 50LͲ.prt<1>[1]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 50LͲ.prt<1>[2]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: rivets for name plate gb_GB_OTHERRIVETS_TYPE93 3X4 (14)
In: Default Storey
PredefinedType: ELEMENT; Material: 0
Name
rivets for name plate gb_GB_OTHERRIVETS_TYPE93 3X4 | PSet_Mass_Property - Mass Measure: 6004.45; Area Measure: 1709144 m2; Volume Measure: 766803 m3
13 x rivets for name plate gb_GB_OTHERRIVETS_TYPE93 3X4
